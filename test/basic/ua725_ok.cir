*ua725 from rainier

*Q3 12 13 14
gm3 12 14 13 14 1.270000e-03
rpi3 13 14 5.260000e+04
ro3 12 14 4.410000e+06
cpi3 13 14 3.980000e-11
cmu3 13 12 5.430000e-12
R4    14  0    2.7K

*Q4 13 13 0
gm4 13 0 13 0 3.850000e-02
rpi4 13 0 3.400000e+03
ro4 13 0 1.320000e+05
cpi4 13 0 5.930000e-11
*cmu4 13 13 1.460000e-11

R3    0   13   29K

*Q15 17 13 11
gm15 17 11 13 11 7.970000e-03
rpi15 13 11 1.420000e+04
ro15 17 11 7.760000e+05
cpi15 13 11 4.420000e-11
cmu15 13 17 4.290000e-12

R5    11  0    220

*Q16 16 13 15
gm16 16 15 13 15 7.850000e-04
rpi16 13 15 8.020000e+04
ro16 16 15 7.850000e+06
cpi16 13 15 3.920000e-11
cmu16 13 16 4.330000e-12

R6    15  0    5.1K

*Q17 25 13 24
gm17 25 24 13 24 7.850000e-04
rpi17 13 24 8.020000e+04
ro17 25 24 7.850000e+06
cpi17 13 24 3.920000e-11
cmu17 13 25 4.330000e-12

R18   24  0    5.1K

*************************************************

*Q1 10 3 12
gm1 10 12 3 12 6.210000e-04
rpi1 3 12 8.890000e+04
ro1 10 12 9.070000e+06
cpi1 3 12 3.900000e-11
cmu1 3 10 5.380000e-12

R1 0 10 52K

*Q2 9 0 12
gm2 9 12 0 12 6.210000e-04
rpi2 0 12 8.890000e+04
ro2 9 12 9.070000e+06
cpi2 0 12 3.900000e-11
cmu2 0 9 5.380000e-12

R2 0 9 52K

*Q6 0 10 16
gm6 0 16 10 16 7.370000e-04
rpi6 10 16 7.340000e+04
ro6 0 16 6.940000e+06
cpi6 10 16 3.930000e-11
cmu6 10 0 1.130000e-11

*Q9 0 9 25
gm9 0 25 9 25 7.370000e-04
rpi9 9 25 7.330000e+04
ro9 0 25 6.940000e+06
cpi9 9 25 3.930000e-11
cmu9 9 0 1.130000e-11

*************************************************

*Q7 20 16 19
gm7 20 19 16 19 2.160000e-03
rpi7 16 19 3.740000e+04
ro7 20 19 1.050000e+06
cpi7 16 19 1.150000e-11
cmu7 16 20 2.050000e-12

*Q8 21 25 19
gm8 21 19 25 19 2.120000e-03
rpi8 25 19 3.760000e+04
ro8 21 19 1.050000e+06
cpi8 25 19 1.150000e-11
cmu8 25 21 2.070000e-12

*Q11 20 20 22
gm11 20 22 20 22 2.080000e-03
rpi11 20 22 3.400000e+04
ro11 20 22 2.440000e+06
cpi11 20 22 4.070000e-11
*cmu11 20 20 1.460000e-11

R8    22  0    2.4K

*Q12 21 20 23
gm12 21 23 20 23 2.080000e-03
rpi12 20 23 3.410000e+04
ro12 21 23 2.450000e+06
cpi12 20 23 4.070000e-11
cmu12 20 21 1.170000e-11
R17   23  0    2.4K

***********************************************

*Q5 17 17 2
gm5 17 2 17 2 7.540000e-03
rpi5 17 2 5.920000e+03
ro5 17 2 1.570000e+05
cpi5 17 2 1.360000e-11
*cmu5 17 17 6.900000e-12

R7    0   2   100

*Q13 27 17 26
gm13 27 26 17 26 9.240000e-03
rpi13 17 26 6.970000e+03
ro13 27 26 1.860000e+05
cpi13 17 26 1.410000e-11
cmu13 17 27 2.570000e-12

R11   0   26   100

*Q10 19 17 18
gm10 19 18 17 18 4.340000e-03
rpi10 17 18 1.020000e+04
ro10 19 18 2.750000e+05
cpi10 17 18 1.250000e-11
cmu10 17 19 6.500000e-12

R10   0   18   300

****************************************
*Q18 27 27 28
gm18 27 28 27 28 2.240000e-04
rpi18 27 28 1.710000e+05
ro18 27 28 2.270000e+07
cpi18 27 28 3.810000e-11
*cmu18 27 27 1.460000e-11

R15   0   27   18K

*Q19 0 28 29
gm19 0 29 28 29 2.370000e-02
rpi19 28 29 5.530000e+03
ro19 0 29 2.380000e+05
cpi19 28 29 5.220000e-11
cmu19 28 0 5.290000e-12

*Q21 0 27 5
gm21 0 5 27 5 5.330000e-03
rpi21 27 5 2.700000e+04
ro21 0 5 1.060000e+06
cpi21 27 5 4.190000e-11
cmu21 27 0 5.350000e-12

*Q23 27 5 6
gm23 27 6 5 6 1.280000e-13
rpi23 5 6 1.910000e+11
ro23 27 6 9.860000e+11
cpi23 5 6 2.610000e-11
cmu23 5 27 1.200000e-11

R16   5  6    25

*************************************************
*Q26 0 29 6
gm26 0 6 29 6 5.300000e-03
rpi26 29 6 1.310000e+04
ro26 0 6 3.290000e+05
cpi26 29 6 1.250000e-11
cmu26 29 0 2.540000e-12

*Q24 21 32 0
gm24 21 0 32 0 6.260000e-13
rpi24 32 0 7.110000e+10
ro24 21 0 9.770000e+11
cpi24 32 0 2.660000e-11
cmu24 32 21 1.020000e-11

R19   31  32   4.5K

*Q14 30 30 31
gm14 30 31 30 31 1.630000e-03
rpi14 30 31 4.090000e+04
ro14 30 31 3.130000e+06
cpi14 30 31 4.030000e-11
*cmu14 30 30 1.460000e-11

R12   32  0    1K

*Q20 29 21 30
gm20 29 30 21 30 2.190000e-03
rpi20 21 30 3.510000e+04
ro20 29 30 2.550000e+06
cpi20 21 30 4.070000e-11
cmu20 21 29 5.530000e-12

*Q22 27 30 33
gm22 27 33 30 33 3.980000e-02
rpi22 30 33 3.610000e+03
ro22 27 33 1.420000e+05
cpi22 30 33 5.980000e-11
cmu22 30 27 5.310000e-12

R13   33  0    150

*Q25 29 30 34
gm25 29 34 30 34 2.190000e-02
rpi25 30 34 5.870000e+03
ro25 29 34 2.560000e+05
cpi25 30 34 5.130000e-11
cmu25 30 29 5.450000e-12

R14   34  0    300

vin 3 0 1

.ac 6 0 dec 8 10 100meg

.end
