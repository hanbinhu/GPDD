*ua741 small signal model from raininer

R5       3   19  39K

*Q17 2 5 7
gm17 2 7 5 7 3.090000e-02
rpi17 5 7 4.410000e+03
ro17 2 7 1.810000e+05
cpi17 5 7 5.560000e-11
cmu17 5 2 5.530000e-12

R8       7   0   100

*Q16 0 1 5
gm16 0 5 1 5 8.550000e-04
rpi16 1 5 7.560000e+04
ro16 0 5 7.240000e+06
cpi16 1 5 3.930000e-11
cmu16 1 0 4.290000e-12

R9       5   0   50K

*Q2 8 0 10
gm2 8 10 0 10 2.560000e-04
rpi2 0 10 1.670000e+05
ro2 8 10 2.210000e+07
cpi2 0 10 3.820000e-11
cmu2 0 8 5.350000e-12

*Q4 1 11 10
gm4 1 10 11 10 2.590000e-04
rpi4 11 10 2.140000e+05
ro4 1 10 6.450000e+06
cpi4 11 10 1.060000e-11
cmu4 11 1 2.650000e-12

*Q6 1 12 15
gm6 1 15 12 15 2.400000e-04
rpi6 12 15 1.630000e+05
ro6 1 15 2.130000e+07
cpi6 12 15 3.820000e-11
cmu6 12 1 1.150000e-11

R2       15  0   1K

*Q5 16 12 13
gm5 16 13 12 13 2.400000e-04
rpi5 12 13 1.630000e+05
ro5 16 13 2.130000e+07
cpi5 12 13 3.820000e-11
cmu5 12 16 1.210000e-11

R1       13  0   1K

*Q7 0 16 12
gm7 0 12 16 12 4.390000e-04
rpi7 16 12 1.220000e+05
ro7 0 12 1.410000e+07
cpi7 16 12 3.860000e-11
cmu7 16 0 4.280000e-12

R3       12  0   50K

*Q3 16 11 17
gm3 16 17 11 17 2.520000e-04
rpi3 11 17 2.210000e+05
ro3 16 17 6.670000e+06
cpi3 11 17 1.060000e-11
cmu3 11 16 2.630000e-12

*Q1 8 18 17
gm1 8 17 18 17 2.480000e-04
rpi1 18 17 1.710000e+05
ro1 8 17 2.270000e+07
cpi1 18 17 3.810000e-11
cmu1 18 8 5.350000e-12

*Q8 8 8 0
gm8 8 0 8 0 4.790000e-04
rpi8 8 0 8.580000e+04
ro8 8 0 2.480000e+06
cpi8 8 0 1.080000e-11
*cmu8 8 8 6.900000e-12

*Q12 3 3 0
gm12 3 0 3 0 2.700000e-02
rpi12 3 0 1.690000e+03
ro12 3 0 4.380000e+04
cpi12 3 0 1.980000e-11
*cmu12 3 3 6.900000e-12

*Q9 11 8 0
gm9 11 0 8 0 7.210000e-04
rpi9 8 0 8.580000e+04
ro9 11 0 2.480000e+06
cpi9 8 0 1.090000e-11
cmu9 8 11 2.470000e-12

*Q11 19 19 0
gm11 19 0 19 0 2.800000e-02
rpi11 19 0 4.420000e+03
ro11 19 0 1.810000e+05
cpi11 19 0 5.430000e-11
*cmu11 19 19 1.460000e-11

*Q10 11 19 14
gm10 11 14 19 14 7.320000e-04
rpi10 19 14 7.870000e+04
ro10 11 14 7.650000e+06
cpi10 19 14 3.920000e-11
cmu10 19 11 5.500000e-12

R4       14  0   5K

*Q13A 20 3 0
gm13A 20 0 3 0 9.850000e-03
rpi13A 3 0 5.440000e+03
ro13A 20 0 1.740000e+05
cpi13A 3 0 1.450000e-11
cmu13A 3 20 2.580000e-12

*Q13B 2 3 0
gm13B 2 0 3 0 3.060000e-02
rpi13B 3 0 2.190000e+03
ro13B 2 0 5.820000e+04
cpi13B 3 0 2.090000e-11
cmu13B 3 2 2.470000e-12

*Q18 20 21 22
gm18 20 22 21 22 9.070000e-03
rpi18 21 22 1.100000e+04
ro18 20 22 5.630000e+05
cpi18 21 22 4.490000e-11
cmu18 21 20 1.200000e-11

R10      21  22  40K

*Q19 20 20 21
gm19 20 21 20 21 7.270000e-04
rpi19 20 21 7.370000e+04
ro19 20 21 6.990000e+06
cpi19 20 21 3.920000e-11
*cmu19 20 20 1.460000e-11

*Q23B 0 2 1
gm23B 0 1 2 1 0.000000e+00
rpi23B 2 1 4.970000e+13
ro23B 0 1 6.710000e+11
cpi23B 2 1 2.740000e-12
cmu23B 2 0 2.570000e-12

*Q23A 0 2 22
gm23A 0 22 2 22 9.730000e-03
rpi23A 2 22 6.630000e+03
ro23A 0 22 1.760000e+05
cpi23A 2 22 1.420000e-11
cmu23A 2 0 2.570000e-12

*Q22 1 23 0
gm22 1 0 23 0 1.090000e-13
rpi22 23 0 2.090000e+11
ro22 1 0 9.780000e+11
cpi22 23 0 2.610000e-11
cmu22 23 1 1.040000e-11

CC       1   2   30P

*Q24 23 23 0
gm24 23 0 23 0 6.230000e-18
rpi24 23 0 2.090000e+11
ro24 23 0 8.930000e+11
cpi24 23 0 2.610000e-11
*cmu24 23 23 1.460000e-11

R11      23  0   50K

*Q20 0 22 24
gm20 0 24 22 24 5.750000e-03
rpi20 22 24 1.210000e+04
ro20 0 24 3.030000e+05
cpi20 22 24 1.270000e-11
cmu20 22 0 2.530000e-12

*Q14 0 20 25
gm14 0 25 20 25 5.790000e-03
rpi14 20 25 2.520000e+04
ro14 0 25 9.730000e+05
cpi14 20 25 4.220000e-11
cmu14 20 0 5.350000e-12

R6       25  9   27

*Q21 23 24 9
gm21 23 9 24 9 0.000000e+00
rpi21 24 9 1.460000e+13
ro21 23 9 5.050000e+11
cpi21 24 9 7.120000e-12
cmu21 24 23 2.500000e-12

R7       9   24  22

*Q15 20 25 9
gm15 20 9 25 9 1.320000e-13
rpi15 25 9 1.890000e+11
ro15 20 9 9.860000e+11
cpi15 25 9 2.610000e-11
cmu15 25 20 1.200000e-11

vin 18 0 1

.ac 9 0 dec 9 1 100meg

.end
