**PMOS input stage CS output stage amplifier

vin1 in1 0 1

**amplifier
**first stage

*M1 y in1 tail 0
RdM1	node1M1	y	1.4400
RsM1	node2M1	tail	1.4400
CbdM1	node1M1	0	1.3171f
CbsM1	node2M1	0	1.3171f
RbdM1	node1M1	0	3.22004715946479e+17
RbsM1	node2M1	0	1.23067263031137e+16
GmM1	node1M1	node2M1	in1	tail	53.7752u
RdsM1	node1M1	node2M1	1010569.03626579
GmbM1	node1M1	node2M1	0	tail	18.6551u
CgsM1	node2M1	in1	3.4015f
CgdM1	node1M1	in1	325.0705a

*M2 x 0 tail 0
RdM2	node1M2	x	1.4400
RsM2	node2M2	tail	1.4400
CbdM2	node1M2	0	1.3171f
CbsM2	node2M2	0	1.3171f
RbdM2	node1M2	0	3.22004715946479e+17
RbsM2	node2M2	0	1.23067263031137e+16
GmM2	node1M2	node2M2	0	tail	53.7752u
RdsM2	node1M2	node2M2	1010569.03626579
GmbM2	node1M2	node2M2	0	tail	18.6551u
CgsM2	node2M2	0	3.4015f
CgdM2	node1M2	0	325.0705a

*M3 y X 0 0
RdM3	node1M3	y	680.0000m
RsM3	node2M3	0	680.0000m
CbdM3	node1M3	0	2.0397f
CbsM3	node2M3	0	2.0397f
RbdM3	node1M3	0	5.07838814339556e+15
RbsM3	node2M3	0	0.1f
GmM3	node1M3	node2M3	X	0	200.8329u
RdsM3	node1M3	node2M3	595841.029613299
GmbM3	node1M3	node2M3	0	0	56.5496u
CgsM3	node2M3	X	5.8609f
CgdM3	node1M3	X	731.1583a

*M4 x x 0 0
RdM4	node1M4	x	680.0000m
RsM4	node2M4	0	680.0000m
CbdM4	node1M4	0	2.0397f
CbsM4	node2M4	0	2.0397f
RbdM4	node1M4	0	5.07838814339556e+15
RbsM4	node2M4	0	0.1f
GmM4	node1M4	node2M4	x	0	200.8329u
RdsM4	node1M4	node2M4	595841.029613299
GmbM4	node1M4	node2M4	0	0	56.5496u
CgsM4	node2M4	x	5.8609f
CgdM4	node1M4	x	731.1583a

*M5 tail Iin 0 0
RdM5	node1M5	tail	30.0000m
RsM5	node2M5	0	30.0000m
CbdM5	node1M5	0	53.8913f
CbsM5	node2M5	0	53.8913f
RbdM5	node1M5	0	352205871492785
RbsM5	node2M5	0	0.1f
GmM5	node1M5	node2M5	Iin	0	177.2152u
RdsM5	node1M5	node2M5	831.946755407654
GmbM5	node1M5	node2M5	0	0	63.0007u
CgsM5	node2M5	Iin	126.2465f
CgdM5	node1M5	Iin	85.0177f

**second stage

*M6 out y 0 0
RdM6	node1M6	out	1.3600
RsM6	node2M6	0	1.3600
CbdM6	node1M6	0	1.1015f
CbsM6	node2M6	0	1.1015f
RbdM6	node1M6	0	289900862.416378
RbsM6	node2M6	0	0.1f
GmM6	node1M6	node2M6	y	0	101.1772u
RdsM6	node1M6	node2M6	1885000.27992254
GmbM6	node1M6	node2M6	0	0	28.6755u
CgsM6	node2M6	y	2.9061f
CgdM6	node1M6	y	363.7438a

*M7 out Iin 0 0
RdM7	node1M7	out	7.2000m
RsM7	node2M7	0	7.2000m
CbdM7	node1M7	0	223.9185f
CbsM7	node2M7	0	223.9185f
RbdM7	node1M7	0	52933253274046.2
RbsM7	node2M7	0	0.1f
GmM7	node1M7	node2M7	Iin	0	42.5351u
RdsM7	node1M7	node2M7	172.628090042812
GmbM7	node1M7	node2M7	0	0	15.2824u
CgsM7	node2M7	Iin	485.1777f
CgdM7	node1M7	Iin	410.5258f

**bias

*M8 Iin Iin 0 0
RdM8	node1M8	Iin	480.0000m
RsM8	node2M8	0	480.0000m
CbdM8	node1M8	0	3.5543f
CbsM8	node2M8	0	3.5543f
RbdM8	node1M8	0	7.99412793837917e+16
RbsM8	node2M8	0	0.1f
GmM8	node1M8	node2M8	Iin	0	78.2244u
RdsM8	node1M8	node2M8	1116122.37656831
GmbM8	node1M8	node2M8	0	0	26.1677u
CgsM8	node2M8	Iin	9.6144f
CgdM8	node1M8	Iin	981.9411a

**compensation
Rz y z 1.75k
Cc z out 350f

**Load
Cl out 0 2p

.ac out 0 dec 10 10 10G

.end
