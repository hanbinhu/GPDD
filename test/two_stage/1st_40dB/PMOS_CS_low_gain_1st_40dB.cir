**PMOS input stage CS output stage amplifier

vin1 in1 0 1

**amplifier
**first stage

*M1 y in1 tail 0
RdM1	node1M1	y	720.0000m
RsM1	node2M1	tail	720.0000m
CbdM1	node1M1	0	2.4357f
CbsM1	node2M1	0	2.4357f
RbdM1	node1M1	0	1.61994010045932e+17
RbsM1	node2M1	0	1.08638620818889e+16
GmM1	node1M1	node2M1	in1	tail	107.5573u
RdsM1	node1M1	node2M1	545791.944110905
GmbM1	node1M1	node2M1	0	tail	36.6663u
CgsM1	node2M1	in1	6.8197f
CgdM1	node1M1	in1	653.0929a

*M2 x 0 tail 0
RdM2	node1M2	x	720.0000m
RsM2	node2M2	tail	720.0000m
CbdM2	node1M2	0	2.4357f
CbsM2	node2M2	0	2.4357f
RbdM2	node1M2	0	1.61994010045932e+17
RbsM2	node2M2	0	1.08638620818889e+16
GmM2	node1M2	node2M2	0	tail	107.5573u
RdsM2	node1M2	node2M2	545791.944110905
GmbM2	node1M2	node2M2	0	tail	36.6663u
CgsM2	node2M2	0	6.8197f
CgdM2	node1M2	0	653.0929a

*M3 y X 0 0
RdM3	node1M3	y	272.0000m
RsM3	node2M3	0	272.0000m
CbdM3	node1M3	0	4.8543f
CbsM3	node2M3	0	4.8543f
RbdM3	node1M3	0	4.83398723667502e+15
RbsM3	node2M3	0	0.1f
GmM3	node1M3	node2M3	X	0	428.9025u
RdsM3	node1M3	node2M3	309042.58606836
GmbM3	node1M3	node2M3	0	0	119.3461u
CgsM3	node2M3	X	14.1441f
CgdM3	node1M3	X	1.8307f

*M4 x x 0 0
RdM4	node1M4	x	272.0000m
RsM4	node2M4	0	272.0000m
CbdM4	node1M4	0	4.8543f
CbsM4	node2M4	0	4.8543f
RbdM4	node1M4	0	4.83398723667502e+15
RbsM4	node2M4	0	0.1f
GmM4	node1M4	node2M4	x	0	428.9025u
RdsM4	node1M4	node2M4	309042.58606836
GmbM4	node1M4	node2M4	0	0	119.3461u
CgsM4	node2M4	x	14.1441f
CgdM4	node1M4	x	1.8307f

*M5 tail Iin 0 0
RdM5	node1M5	tail	30.0000m
RsM5	node2M5	0	30.0000m
CbdM5	node1M5	0	53.8913f
CbsM5	node2M5	0	53.8913f
RbdM5	node1M5	0	535337837650663
RbsM5	node2M5	0	0.1f
GmM5	node1M5	node2M5	Iin	0	354.6655u
RdsM5	node1M5	node2M5	1000.91002739691
GmbM5	node1M5	node2M5	0	0	124.6137u
CgsM5	node2M5	Iin	136.9725f
CgdM5	node1M5	Iin	67.1434f

**second stage

*M6 out y 0 0
RdM6	node1M6	out	45.3333m
RsM6	node2M6	0	45.3333m
CbdM6	node1M6	0	28.3097f
CbsM6	node2M6	0	28.3097f
RbdM6	node1M6	0	14517280.543831
RbsM6	node2M6	0	0.1f
GmM6	node1M6	node2M6	y	0	2.7715m
RdsM6	node1M6	node2M6	80164.8188675918
GmbM6	node1M6	node2M6	0	0	766.4123u
CgsM6	node2M6	y	85.1213f
CgdM6	node1M6	y	10.9764f

*M7 out Iin 0 0
RdM7	node1M7	out	10.0000m
RsM7	node2M7	0	10.0000m
CbdM7	node1M7	0	161.2769f
CbsM7	node2M7	0	161.2769f
RbdM7	node1M7	0	196809516096218
RbsM7	node2M7	0	0.1f
GmM7	node1M7	node2M7	Iin	0	1.1981m
RdsM7	node1M7	node2M7	351.728746790475
GmbM7	node1M7	node2M7	0	0	419.6783u
CgsM7	node2M7	Iin	418.5463f
CgdM7	node1M7	Iin	186.9966f

**bias

*M8 Iin Iin 0 0
RdM8	node1M8	Iin	480.0000m
RsM8	node2M8	0	480.0000m
CbdM8	node1M8	0	3.5543f
CbsM8	node2M8	0	3.5543f
RbdM8	node1M8	0	7.99412793837917e+16
RbsM8	node2M8	0	0.1f
GmM8	node1M8	node2M8	Iin	0	78.2244u
RdsM8	node1M8	node2M8	1116122.37656831
GmbM8	node1M8	node2M8	0	0	26.1677u
CgsM8	node2M8	Iin	9.6144f
CgdM8	node1M8	Iin	981.9411a

**compensation
Rz y z 1.75k
Cc z out 350f

**Load
Cl out 0 2p

.ac out 0 dec 10 10 10G

.end
